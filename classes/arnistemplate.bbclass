export URHO3D_HOME = "${STAGING_DIR_HOST}/usr"

EXTRA_OECMAKE = "-DCMAKE_BUILD_TYPE=Debug"

sassetsdir = "/bin"

inherit cmake
